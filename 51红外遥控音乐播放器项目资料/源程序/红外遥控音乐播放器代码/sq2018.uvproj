# Keil uVision project sq2018.uvproj, settings and files
target IR-MENU (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: sq2018 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\bsp;.\app\inc;.\bsp\inc
  group app
    ./: STARTUP.A51
    ./app/src/: main.c
    ./bsp/src/: bsp_music.c
  group bsp
    ./bsp/: bsp.c
    ./bsp/src/: bsp_delay.c bsp_lcd1602.c bsp_int.c bsp_timer.c bsp_ir.c bsp_serial.c
  group doc
    ./: explain.txt
